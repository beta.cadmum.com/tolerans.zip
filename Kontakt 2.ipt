# Autodesk Inventor part: Kontakt 2
## iProperties
Created: 2005-11
Part Number: Kontakt 2
Document SubType Name: Modeling
Designer: Karl-Axel B
Author: Karl-Axel B
## Feature names
1. Extrusion1
