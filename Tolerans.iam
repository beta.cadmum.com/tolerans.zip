# Autodesk Inventor assembly: Tolerans
## iProperties
Created: 2005-11
Part Number: Tolerans
Document SubType Name: Assembly
Designer: Karl-Axel B
Author: Karl-Axel B
